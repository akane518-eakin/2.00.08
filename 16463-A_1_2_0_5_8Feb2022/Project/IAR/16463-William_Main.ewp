# IAR project 16463-William_Main.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; IAR_DEBUG
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\APP; ..\..\ALG; ..\..\API; ..\..\Drivers\STM32; ..\..\Drivers\S25FL0xx; ..\..\Drivers\LTC2943; ..\..\Drivers\AD7794; ..\..\Drivers\Paracube; ..\..\Drivers\TianmaGraphics\Application; ..\..\Drivers\TianmaGraphics\drivers; ..\..\Drivers\TianmaGraphics\Bitmaps; ..\..\Drivers\TianmaGraphics\Fonts; ..\..\Drivers\TianmaGraphics\Language; ..\..\PCB; ..\..\3rdParty\ST\CMSIS\CM3\CoreSupport; ..\..\3rdParty\ST\CMSIS\CM3\CoreSupport\core_cm3_8_11; ..\..\3rdParty\ST\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\3rdParty\ST\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 16463-William_Main.bin
  ILINK.IlinkOutputFile: 16463-William_Main.out
  ILINK.IlinkIcfFile: STM32F103ZE_FLASH.icf
  ILINK.IlinkExtraOptions: --place_holder ielftool_checksum,2,file_checksum,4; --keep=ielftool_checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: PF8-14411-A.srec
  ILINK.IlinkOutputFile: PF8-14411-A.out
configuration Debug_6_0 (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\APP; ..\..\ALG; ..\..\API; ..\..\Drivers\STM32; ..\..\Drivers\S25FL0xx; ..\..\Drivers\LTC2943; ..\..\Drivers\AD7794; ..\..\Drivers\Paracube; ..\..\Drivers\TianmaGraphics\Application; ..\..\Drivers\TianmaGraphics\drivers; ..\..\Drivers\TianmaGraphics\Bitmaps; ..\..\Drivers\TianmaGraphics\Fonts; ..\..\Drivers\TianmaGraphics\Language; ..\..\PCB; ..\..\3rdParty\ST\CMSIS\CM3\CoreSupport; ..\..\3rdParty\ST\CMSIS\CM3\CoreSupport\core_cm3_6_0; ..\..\3rdParty\ST\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\3rdParty\ST\STM32F10x_StdPeriph_Driver\inc
configuration Debug_8_11 (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  group 3rdParty/ST/CMSIS/CM3/CoreSupport
    ../../3rdParty/ST/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
  group 3rdParty/ST/CMSIS/CM3/DeviceSupport/ST/STM32F10x
    ../../3rdParty/ST/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group 3rdParty/ST/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar
    ../../3rdParty/ST/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
  group 3rdParty/ST/STM32F10x_StdPeriph_Driver/inc
    ../../3rdParty/ST/STM32F10x_StdPeriph_Driver/inc/: cortexm3_macro.h misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_conf.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_it.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group 3rdParty/ST/STM32F10x_StdPeriph_Driver/src
    ../../3rdParty/ST/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group ALG
    ../../ALG/: alg_av.c alg_av.h alg_butterworth.c alg_butterworth.h alg_filt.c alg_filt.h alg_NTC_thermistor.c alg_NTC_thermistor.h alg_pid.c alg_pid.h alg_temp_comp.c alg_temp_comp.h
  group API
    ../../API/: api_audio.c api_audio.h api_bootloader.c api_bootloader.h api_bootloader_comms.c api_bootloader_comms.h api_calibrate.c api_calibrate.h api_EmbededCodeVars.c api_EmbededCodeVars.h api_Err.c api_Err.h api_IO.c api_IO.h api_LEDs.c api_LEDs.h api_Reset.c api_Reset.h api_RGB.c api_RGB.h api_RTC.c api_RTC.h api_SerialNo.c api_SerialNo.h api_STM32_touchscreen.c api_STM32_touchscreen.h api_STM32_uniqueID.c api_STM32_uniqueID.h api_stopwatch.c api_stopwatch.h api_watchdog.c api_watchdog.h
  group APP
    ../../APP/: app_battery_fuel_guage.c app_battery_fuel_guage.h app_button.c app_button.h app_debug.c app_debug.h app_patient_pressure.c app_patient_pressure.h app_pneumatic_ctrl.c app_pneumatic_ctrl.h app_selfcheck.c app_selfcheck.h app_system.c app_system.h app_touchscreen.c app_touchscreen.h app_UI.c app_UI.h glb_typedefs.h main.c stm32f10x_it.c stm32f10x_it.h
  group Drivers/AD7794
    ../../Drivers/AD7794/: csp_AD7794.c csp_AD7794.h tst_AD7794.c tst_AD7794.h
  group Drivers/LTC2943
    ../../Drivers/LTC2943/: csp_ltc2943.c csp_ltc2943.h hal_ltc2943.c hal_ltc2943.h tst_ltc2943.c tst_ltc2943.h
  group Drivers/Paracube
    ../../Drivers/Paracube/: csp_paracube_O2.c csp_paracube_O2.h tst_paracube_O2.c tst_paracube_O2.h
  group Drivers/S25FL0xx
    ../../Drivers/S25FL0xx/: csp_S25FL0xx.c csp_S25FL0xx.h S25FL0xx.c S25FL0xx.h tst_S25FL0xx.c tst_S25FL0xx.h
  group Drivers/STM32
    ../../Drivers/STM32/: csp_STM32_adc1.c csp_STM32_adc1.h csp_STM32_adc2.c csp_STM32_adc2.h csp_STM32_clks.c csp_STM32_clks.h csp_STM32_dac.c csp_STM32_dac.h csp_STM32_delay.c csp_STM32_delay.h csp_STM32_dma.c csp_STM32_dma.h csp_STM32_fsmc.c csp_STM32_fsmc.h csp_STM32_I2Cx.c csp_STM32_I2Cx.h csp_STM32_interrupts.c csp_STM32_interrupts.h csp_STM32_iwdg.c csp_STM32_iwdg.h csp_STM32_rtc.c csp_STM32_rtc.h csp_STM32_spi.h csp_STM32_spi1.c csp_STM32_spi1.h csp_STM32_spi2.c csp_STM32_spi2.h csp_STM32_timer1.c csp_STM32_timer1.h csp_STM32_timer2.c csp_STM32_timer2.h csp_STM32_timer3.c csp_STM32_timer3.h csp_STM32_timer4.c csp_STM32_timer4.h csp_STM32_timer8.c csp_STM32_timer8.h csp_STM32_uart.c csp_STM32_uart.h csp_STM32_uart1.c csp_STM32_uart1.h csp_STM32_uart2.c csp_STM32_uart2.h csp_STM32_uart4.c csp_STM32_uart4.h csp_STM32_uart5.c csp_STM32_uart5.h hal_STM32_uart.c hal_STM32_uart.h
  group Drivers/TianmaGraphics/Application
    ../../Drivers/TianmaGraphics/Application/: bfcfont.h Colours.h globtypes.h hal_lcd.c hal_lcd.h hal_lcd_text.c hal_lcd_text.h tst_LCD.c tst_LCD.h
  group Drivers/TianmaGraphics/Bitmaps
    ../../Drivers/TianmaGraphics/Bitmaps/: bitmaps.c bitmaps.h IMG_Adjust50.c IMG_Adjust50.h IMG_AlarmActive.c IMG_AlarmActive.h IMG_Alarmbell.c IMG_Alarmbell.h IMG_AlarmMuteIcon.c IMG_AlarmMuteIcon.h IMG_AlarmSilence.c IMG_AlarmSilence.h IMG_AlarmVol.c IMG_AlarmVol.h IMG_Armstrong.c IMG_Armstrong.h IMG_Armstrong_Logo.c IMG_Armstrong_Logo.h IMG_BackArrow.c IMG_BackArrow.h IMG_Beep50.c IMG_Beep50.h IMG_Brightness51.c IMG_Brightness51.h IMG_Circle_Go.c IMG_Circle_Go.h IMG_Circle_X.c IMG_Circle_X.h IMG_Cross_65_65.c IMG_Cross_65_65.h IMG_EndStopL.c IMG_EndStopL.h IMG_EndStopR.c IMG_EndStopR.h IMG_FD140i.c IMG_FD140i.h IMG_Gear.c IMG_Gear.h IMG_Gear1.c IMG_Gear1.h IMG_Hourglass50.c IMG_Hourglass50.h IMG_Language50.c IMG_Language50.h IMG_Locked.c IMG_Locked.h IMG_Medical.c IMG_Medical.h IMG_NebuliserActivated.c IMG_NebuliserActivated.h IMG_NebuliserDeactivated.c IMG_NebuliserDeactivated.h IMG_NextArrow.c IMG_NextArrow.h IMG_Progress_01.c IMG_Progress_01.h IMG_Progress_02.c IMG_Progress_02.h IMG_Progress_03.c IMG_Progress_03.h IMG_Progress_04.c IMG_Progress_04.h IMG_Progress_05.c IMG_Progress_05.h IMG_Progress_06.c IMG_Progress_06.h IMG_Progress_07.c IMG_Progress_07.h IMG_Progress_08.c IMG_Progress_08.h IMG_Progress_09.c IMG_Progress_09.h IMG_Progress_10.c IMG_Progress_10.h IMG_Progress_11.c IMG_Progress_11.h IMG_Progress_12.c IMG_Progress_12.h IMG_Progress_13.c IMG_Progress_13.h IMG_Progress_14.c IMG_Progress_14.h IMG_Progress_15.c IMG_Progress_15.h IMG_Progress_16.c IMG_Progress_16.h IMG_SliderIconHandD.c IMG_SliderIconHandD.h IMG_SliderIconHandU.c IMG_SliderIconHandU.h IMG_SliderPinD.c IMG_SliderPinD.h IMG_SliderPinU.c IMG_SliderPinU.h IMG_Smell50.c IMG_Smell50.h IMG_Tic_65_65.c IMG_Tic_65_65.h IMG_Unlocked.c IMG_Unlocked.h IMG_Unplugged_Icon.c IMG_Unplugged_Icon.h IMG_Vol50.c IMG_Vol50.h IMG_Warning_Icon_60x60.c IMG_Warning_Icon_60x60.h IMG_WarningIcon.c IMG_WarningIcon.h
  group Drivers/TianmaGraphics/drivers
    ../../Drivers/TianmaGraphics/drivers/: csp_LCD_SSD1963.c csp_LCD_SSD1963.h
  group Drivers/TianmaGraphics/Fonts
    ../../Drivers/TianmaGraphics/Fonts/: Arial16h.c Arial22h.c Arial26h.c Arial48h.c ArialNarrow37h.c ArialNarrow50h.c ArialNarrow60h.c ArialNarrowBold31h.c fonts.c fonts.h
  group Drivers/TianmaGraphics/Language
    ../../Drivers/TianmaGraphics/Language/: Arabic.c Dutch.c English.c Finnish.c French.c German.c Greek.c Indonesian.c Italian.c Language.c Language.h Latvian.c Norwegian.c Polish.c Portuguese.c Romanian.c Spanish.c Swedish.c Turkish.c Vietnamese.c
  group PCB
    ../../PCB/: pcb_interrupts.h pcb_mem_map_flash.h pcb_pins.c pcb_pins.h pcb_spi1.c pcb_spi1.h pcb_spi2.c pcb_spi2.h pcb_startup.c pcb_startup.h pcb_timer.h pcb_uart.h pcb_uart1.h pcb_uart2.h pcb_uart4.h pcb_uart5.h
